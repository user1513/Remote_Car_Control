# Keil uVision project app.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: app +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\HARDWARE\ccp;..\HARDWARE\djiReceiver_dr16;..\HARDWARE\timer1;..\HARDWARE\uart1;..\HARDWARE\uart2;..\HARDWARE\uart3;..\HARDWARE\TableTennisDevice;..\HARDWARE\ModbusCRC16
  group USER
    ./: STARTUP.A51 app.c
  group HARDWARE
    ../HARDWARE/djiReceiver_dr16/: djiReceiver_dr16.c
    ../HARDWARE/timer1/: timer1.c
    ../HARDWARE/uart1/: uart1.c
    ../HARDWARE/uart2/: uart2.c
    ../HARDWARE/uart3/: uart3.c
    ../HARDWARE/ModbusCRC16/: ModbusCRC16.c
    ../HARDWARE/ccp/: ccp.c
  group Readme
    ../: readme.txt
